v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {/foss/designs/SAR_ADC_8_Bit_IHP130/COMP/COMP_NMOS_IP.sym} 400 -90 0 0 {name=x1}
